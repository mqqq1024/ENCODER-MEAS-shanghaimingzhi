# Keil uVision project AIP-MOTOR-ENCODER-10.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AIP-MOTOR-ENCODER-10 +hex
  group src
    ../src/: main.c adc.c timer1.c exti.c serial.c uart_com.c led.c encoder_meas.c dft.c table.c table_f.c delay.c user_api.c syscalls.c
  group STM32lib
    ../src/STM32lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../src/STM32lib/startup/: startup_stm32f10x_hd.s
  group Freertos
    ../src/freertos/: heap_2.c list.c port.c queue.c tasks.c timers.c
